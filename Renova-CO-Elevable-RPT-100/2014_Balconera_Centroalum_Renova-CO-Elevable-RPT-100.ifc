Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número de proyecto
Time: 2016-06-07T15:31:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 07 15:31:38 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{2849D240-5220-4A71-B096-B7CEADA4590C}\ifc * Database version: 5507 * Database creation date: Tue Jun 07 15:31:37 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 07 15:31:38 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 07 15:31:38 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número de proyecto
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 0, 86975; RefLongitude: -3, -42, -1, -243858; RefElevation: 0 m
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: Número de proyecto; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: Número de proyecto; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 m
Other - Category: Levels; Family Name: Level; Family: Level: Nivel 1; Family and Type: Level: Nivel 1; Type: Level: Nivel 1; Type Id: Level: Nivel 1
Constraints - Elevation: 0 m; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Name: Nivel 1; Structural: no; Type Name: Nivel 1
Graphics - Color: 0; Line Pattern: Trazo punto; Line Weight: 1; Symbol: Extremo de nivel: Extremo de nivel; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcWindow: Balconera 2 hojas 1480x2180, 2014_Balconera_Centroalum_Renova-CO-Elevable-RPT-100:Balconera 2 hojas 1480x2180:154039
In: Nivel 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Aluminio, Vidrio
Type - Analysis Results - FactorSolarModificado: 0; FactorSombra: 0; FracciónÁreaAcristalamiento: 0; PermeabilidadAlAire: Clase 3; Transmitancia térmica Marco/Hoja (Uh/m): 4,7 (W/m2 K); Transmitancia térmica Nudo central (Uh/m): 4,0(W/m2 K)
Type - Analytical Properties - Analytic Construction: <None>
Type - Construction - Altura de antepecho por defecto: 0 m; CerramientoExterior: yes; Configuración de poliamidas: 961759 // 209900; ControlHumos: no; Máximo hueco acristalar (mm): 0.031 m; Motorizada: no; PERFILES SECCIÓN - Hoja: 86.2000; PERFILES SECCIÓN - Junquillo: Según espesor camara; PERFILES SECCIÓN - Marco: 86.1100 / 86.1200 / 86.1300/86.1770; RepisaExterior: no; RepisaInterior: no; Rotura de puente térmico (mm): 24 (marco) / 12 (hoja); SalidaEmergencia: no; Sección de hoja (mm): 42,5 mm; Sección de marco (mm): 103 mm; Wall Closure: By host
Type - Data - Área: 3.1174 m2; EstanqueidadAgua: Clase 4A; MasaSuperficialKgm2: 0; ResistenciaAlViento: Clase C1; TransmitanciaTérmica: 2
Type - Dimensions - AlturaManija: 1 m; DesfaseExterior: 0 m; DM_AlturaCristal: 2.1115 m; GrosorMarco: 0.103 m; Height: 2.18 m; LíneaProyección: 0.70516 m; Width: 1.43 m
Type - General - CosteMantenimiento: 0; MateriaPrima: 0
Type - Green Building Properties - AcidificaciónAtmosférica: 0; AcidificaciónAtmosféricaPorUnidad: 0; AguaConsumidaPorUnidad: 0; CambioClimático: 0; CambioClimáticoPorUnidad: 0; ConsumoAgua: 0; CosnsumoEnergíaPrimariaTotal: 0; CosteEnergéticoKwh: 0; CosteEnergéticoMj: 0; DestrucciónCapaOzonoEstratosférica: 0; DestrucciónCapaOzonoEstratosféricaPorUnidad: 0; EmisiónCO2: 0; EnergíaNoRenovableConsumida: 0; EnergíaNoRenovableConsumidaPorUnidad: 0; EnergíaPrimariaTotalConsumidaPorUnidad: 0; EnergíaRenovableConsumida: 0; EnergíaRenovableConsumidaPorUnidad: 0; Eutrofización: 0; EutrofizaciónPorUnidad: 0; FaltaDeRecurso: 0; FaltaDeRecursosPorUnidad: 0; FormaciónFotoquímicaOzono: 0; FormaciónFotoquímicaOzonoPorUnidad: 0; ResiduoInerte: 0; ResiduoInertePorUnidad: 0; ResiduoRadioactivo: 0; ResiduoRadioactivoPorUnidad: 0; ResiduosNoPeligrosos: 0; ResiduosNoPeligrososPorUnidad: 0; ResiduosPeligrosos: 0; ResiduosPeligrososPorUnidad: 0
Type - Identity Data - Autor: Bimetica Parametric Design Services, S.L.; Bimetica: http://www.bimetica.com; CódigoMasterformat: 08 51 13 - Aluminium Windows; CódigoUniclass2.0: 25-30 - Door and window systems; CódigoUNSPSC: 30171600 - Windows; Description: Balconera 2 hojas 1480 x 2180; FechaEmisiónElementoBIM: 11/05/2016; FechaVencimientoElementoBIM: 01/01/2017; Manufacturer: CENTROALUM SA; Model: Renova CO RPT Elevable 100; OmniClass Number: 23.30.20.00; OmniClass Title: Windows; ReferenciaContacto: Departamento Técnico de Centroalum; TeléfonoContacto: +34 93 712 29 11; Type Mark: 21; Type Name: Balconera 2 hojas 1480x2180; URL: http://centroalum.com/; URL Poliamida: http://www.technoform.es/; URL Poliamida - Catálogo: http://www.technoform.com/fileadmin/Technoform_Bautec/standardprofiles.html; URLProducto: http://centroalum.com/es/Windows/46/284/; VersiónElementoBIM: 1.0
Type - Materials and Finishes - Acabado: Lacado colores RAL / Lacado colores especiales / Lacado imitación madera / Lacado madera polvo sobre polvo / Anodizado / Posibilidad Bicolor; Acristalamiento: Vidrio; Marco: Aluminio; Poliamida: Poliamida, Technoform Bautec, PA66 GF 25
Type - Other - Category: Windows; Family Name: 2014_Balconera_Centroalum_Renova-CO-Elevable-RPT-100
OverallHeight: 2.18 m; OverallWidth: 1.43 m
Pset_WindowCommon - Reference: Balconera 2 hojas 1480x2180; IsExternal: yes
Pset_ManufacturerTypeInformation - Manufacturer: CENTROALUM SA
Constraints - Level: Level: Nivel 1; Sill Height: 0 m
Dimensions - Area: 6.99143 m2; DesfaseInterior: 0 m; Volume: 0.0862739 m3
Identity Data - Mark: 2
Other - Family: 2014_Balconera_Centroalum_Renova-CO-Elevable-RPT-100: Balconera 2 hojas 1480x2180; Family and Type: 2014_Balconera_Centroalum_Renova-CO-Elevable-RPT-100: Balconera 2 hojas 1480x2180; Head Height: 2.18 m; Host Id: Basic Wall: Por defecto - 20 cm; Type: 2014_Balconera_Centroalum_Renova-CO-Elevable-RPT-100: Balconera 2 hojas 1480x2180; Type Id: 2014_Balconera_Centroalum_Renova-CO-Elevable-RPT-100: Balconera 2 hojas 1480x2180
Phasing - Phase Created: Nueva construcción
Visibility - Detalle Perfileria: no; Manija: yes; Proyección Apertura: no
